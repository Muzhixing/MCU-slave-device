# Keil uVision project F407_HAL_Template.uvprojx, settings and files
target F407_HAL_Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(168000000) FPU2 CPUTYPE("Cortex-M4")
  output: F407_HAL_Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE=8000000U
  c include: ../User;../Hardware;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group User
    ../User/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c
  group Drivers/CMSIS
    ../User/: system_stm32f4xx.c
  group Hardware
    ../Hardware/: UpperPacket.c UpperPacket.h AxisControl.c AxisControl.h SystemControl.c AxisFeedback.c DriverCAN.c DriverCANDecode.c SystemControl.h StepperPulse.c StepperPulse.h motor.c motor.h MotorSpeedPID.c MotorSpeedPID.h MotorEncoder.c MotorEncoder.h MotorEncoderMath.c MotorControl.c MotorControl.h Bluetooth.c Bluetooth.h HWT101.c HWT101.h HWT101_Parser.c HWT101_Parser.h Servo.c Servo.h ultrasound.c ultrasound.h water_pump.c water_pump.h
