#include "line_trace.h"

/**********************************************************************
 * 函数功能：8路红外循迹传感器权重数组
 * 硬件定义：bit0 = 最左侧传感器，bit7 = 最右侧传感器
 * 权重含义：左侧传感器为负权重，右侧为正权重，中间传感器权重为0
 * 作用：用于加权计算小车偏离黑线的误差值
 **********************************************************************/
static const int8_t sensor_weights[] = {-3, -2, -1, 0, 0, 1, 2, 3};

// 轨迹特殊标记的特征图案（用于识别终点/特殊标识）
#define TRACE_MARKER_PATTERN 0xAF
// 识别到特殊标记时的误差值
#define TRACE_MARKER_ERROR 40

// 全白状态标志：1=传感器检测到全白（无黑线），0=未检测到
static uint8_t full_white_seen = 0;

// 停止请求标志：1=请求小车停止循迹，0=正常循迹
uint8_t stop_request = 0;

extern uint32_t count;

uint8_t request = 0;
/**********************************************************************
 * 函数名称：line_trace_init
 * 功能描述：循迹模块初始化函数
 * 入口参数：无
 * 返 回 值：无
 * 作用：重置全局状态标志，为循迹做准备
 **********************************************************************/
void line_trace_init(void)
{
    full_white_seen = 0;  // 清空全白检测标志
    stop_request = 0;     // 清空停止请求标志
}

/**********************************************************************
 * 函数名称：line_trace_stop_requested
 * 功能描述：获取循迹停止请求状态
 * 入口参数：无
 * 返 回 值：uint8_t 1=需要停止，0=继续运行
 **********************************************************************/
uint8_t line_trace_stop_requested(void)
{
    return stop_request;
}

/**********************************************************************
 * 函数名称：line_trace_get_error
 * 功能描述：根据8路传感器原始数据，计算循迹偏差值（核心算法）
 * 入口参数：uint8_t sensor_data 8位传感器数据（bit0~bit7对应8路传感器）
 * 返 回 值：int32_t 循迹误差值（负数=左偏，正数=右偏，0=居中）
 **********************************************************************/
int32_t line_trace_get_error(uint8_t sensor_data)
{
    int32_t error = 0;  // 定义误差值变量，初始化为0

    // 处理传感器特殊状态
    // 规则：bit0最左侧传感器，bit7最右侧传感器 | 0=检测到黑线，1=检测到白底
    switch (sensor_data)
    {
        // 0xFF = 二进制 11111111 | 8路传感器全部检测到黑色（完全在黑线上）
        case 0xFF:
                error = 0;
            break;
        
        // 0x00 = 二进制 00000000 | 8路传感器全部检测到白色（脱离轨迹）
        case 0x00:
            error = 0;
            break;
		
        // 0xC7 = 二进制 11000111 | 自定义特殊传感器图案
        case 0xC7:
			
		if(request ==0){
			if(stop_request==0) {
				
				stop_request=1;
				error = 0;
			}	
			
			else
			{
				
			if(count>150){				
				error=30;
				count=0;
				request==1;
				}				
				else {error = 0;}				
		} 
	
}			
		else	error = 0;	

            break;
		
        // 0x0F = 二进制 00001111 | 左侧4个传感器检测到黑线
        case 0x0F:
                error = -35;  // 左偏误差
                break;   				
        
        // 0xF0 = 二进制 11110000 | 右侧4个传感器检测到黑线
        case 0xF0:
                error = 35;   // 右偏误差
                break;

        // 默认情况：传感器检测到部分黑线，执行加权计算
        default:
            // 遍历8路传感器，计算加权误差
            for (int i = 0; i < 8; i++)
            {
                // 传感器检测到黑线时，对应位为0，累加权重
                if ((sensor_data & (1U << i)) == 0U)
                {
                    error += sensor_weights[i];
                }
            }

            error *= 16;  // 误差值放大16倍，提高控制精度
            
            // 一级限幅：将误差限制在 [-48, 48] 之间
            if (error > 48) {
                error = 48;
            } else if (error < -48) {
                error = -48;
            }
            break;
    }

    // 二级限幅：最终误差限制在 [-50, 50] 之间，防止输出过大
    if (error > 50) {
        error = 50;
    } else if (error < -50) {
        error = -50;
    }

    return error;
}
/**********************************************************************
 * 函数名称：line_trace_sensor_to_binary
 * 功能描述：将8位传感器数据转换为二进制字符串（调试用）
 * 入口参数：uint8_t sensor_data 传感器原始数据
 *           char *buffer 存储二进制字符串的缓冲区（需≥9字节）
 * 返 回 值：无
 * 输出格式：8位二进制字符串，例如传感器数据0x0F → "00001111"
 **********************************************************************/
void line_trace_sensor_to_binary(uint8_t sensor_data, char *buffer)
{
    // 从最高位bit7到最低位bit0，逐位转换为字符'0'/'1'
    for (int i = 7; i >= 0; i--)
    {
        buffer[7 - i] = (sensor_data & (1U << i)) ? '1' : '0';
    }
    buffer[8] = '\0';  // 添加字符串结束符，防止乱码
}
